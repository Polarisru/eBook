# Keil uVision project eBook.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: eBook
  c flags: Optim=1
  c define: STM32L053xx
  c include: .\CMSIS;.\Sources;.\Drivers
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ./CMSIS/: startup_stm32l053xx.s system_stm32l0xx.c
  group SourceCode
    ./Sources/: main.c
  group Drivers
    ./Drivers/: spi.c clock.c
target Release (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: as above
  output: eBook
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
